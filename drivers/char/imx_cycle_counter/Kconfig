## drivers/char/imx_cycle_counter/Kconfig
```kconfig
#
# imx6q pmu
#

config USER_ACCESS_CYCLE_COUNTER
    tristate "Enable user mode access to processor cycle counters"
    default y
```
